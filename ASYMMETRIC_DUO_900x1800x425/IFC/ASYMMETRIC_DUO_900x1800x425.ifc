Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2016-04-19T11:09:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 19 11:09:41 2016 * Host: Calatrava * Database: C:\Users\UTILIS~1\AppData\Local\Temp\{68E8AF96-CC00-48D9-A641-9D419392604F}\ifc * Database version: 5507 * Database creation date: Tue Apr 19 11:09:38 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 19 11:09:38 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 19 11:09:38 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\Temp\KDW010001\KDW010001.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Autre - Catégorie: Informations sur le projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Plein; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Autre - Catégorie: Niveaux; Famille: Niveau: Niveau 1; Famille et type: Niveau: Niveau 1; ID du type: Niveau: Niveau 1; Type: Niveau: Niveau 1; Nom de la famille: Niveau
Contraintes - Elévation: 0 mm; Base de l'élévation: Point de base du projet
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no; Nom du type: Niveau 1

# IfcFlowTerminal: Kaldewei 742 Asymmetric Duo 1800x900, Kaldewei 742 Asymmetric Duo 1800x900:Kaldewei 742 Asymmetric Duo 1800x900:3661
In: Niveau 1
Material: Steel enamel
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI
Pset_DistributionFlowElementCommon - Reference: Kaldewei 742 Asymmetric Duo 1800x900
Autre - Catégorie: Appareils sanitaires; Famille: Kaldewei 742 Asymmetric Duo 1800x900: Kaldewei 742 Asymmetric Duo 1800x900; Famille et type: Kaldewei 742 Asymmetric Duo 1800x900: Kaldewei 742 Asymmetric Duo 1800x900; ID du type: Kaldewei 742 Asymmetric Duo 1800x900: Kaldewei 742 Asymmetric Duo 1800x900; Type: Kaldewei 742 Asymmetric Duo 1800x900: Kaldewei 742 Asymmetric Duo 1800x900; Code UNSPSC: 30181500; Nom de la famille: Kaldewei 742 Asymmetric Duo 1800x900; Technical description: http://www.kaldewei.co.uk/fileadmin/data/sprachen/englisch/techdata/KADBE_ASYMMETRICDUO_______742__.pdf; Uniclass 2015 Code: Pr_40_20_06_08; Uniclass 2015 Description: Baths; Water volume in litres (70l displacement on average): 163
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no; Distance bath edge (foot end) to where grip/handle ends: 1047,5 mm; Distance bath edge (foot end) to where grip/handle starts: 752,5 mm; Distance bath edge to centre of drain hole: 900 mm; Distance between centre holes: 335 mm; Distance between the feet: 640 mm; Distance foot end of bath edge to centre of foot: 580 mm; Distance top edge to centre of overflow hole: 70 mm
Cotes - Surface: 2.8668 m2; Volume: 0.00927846 m3; Depth: 420mm; Length: 1800mm; Width: 900mm
Données d'identification - Identifiant: 1; Description: A bath with a comfort zone: with its generously proportioned storage shelf, the ASYMMETRIC DUO also has a spatial dimension. It can be used as a seat or for holding bath utensils, and also for the individual positioning of taps. There is a charming contrast between the precise and clear form of the bath rim and the ergonomic, flowing design language of the inside. Furthermore, the outflow set flush into the base of the bath is an elegant and harmonious solution.; Fabricant: KALDEWEI; Keynote: exciting contrast between the clear lines of the bath rim and the flowing, ergonomic design language of the interior; generously sized storage area that can also be used as a sit or to accommodate bath rim tap fittings, enamelled waste cover and overflow knob integrated in the bath design, bathing with a friend: two identical back rests and centrally positioned waste, made of KALDEWEI steel enamel; Maufacturer Country: Germany; Modèle: Kaldewei ASSYMETRIC DUO 742, 180 x 90 x 42 cm; Nom du type: Kaldewei 742 Asymmetric Duo 1800x900; Nom UNSPSC: Sanitary ware; Product name: ASSYMETRIC DUO; URL: http://www.kaldewei.de/produkte/badewannen/avantgarde/detail/product/asymmetric-duo.html
Phase de construction - Phase de création: Nouvelle construction
Construction - Anti-slip: 396 x 396 mm; Diameter of drain hole: 52 mm; Diameter of overflow hole: 52 mm; Full anti-slip: 876 x 252 mm; Height of rim: 32 mm; Height with feet: 540-560 mm; Internal length (bottom): 1348 mm; Internal length (top): 1670 mm; Internal width (bottom): 600 mm; Internal width (top): 681 mm; Max. width of feet: 525 mm; Shelf (width): 157 mm; Width of rim (foot end lengthwise): 65; 62 mm
Général - Colour: alpine white, optional: further sanitary ware colours; Materials and finitions: Steel enamel; Normes: Surface impact, scratch and abrasion resistant, colourfast, lightfast and acid resistant according to DIN ISO 28706-1 and DIN EN 14516, CE-marking regarding to DIN EN 14516-CL1+CL2, TÜV GS certificated (tested safety), rim slopes slightly to the inside of the bath, earthing strap for equipotential bonding, 100 % recyclable and certified with the IBU environmental product-declaration according to ISO 14025, 30-year guarantee for bathtubs
Matériaux et finitions - Matériau: Steel enamel
